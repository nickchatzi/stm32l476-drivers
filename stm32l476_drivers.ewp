# IAR project stm32l476_drivers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.PreInclude: C:\Users\nickh\Desktop\embedded\stm32l476 drivers\drivers\startup\startup_stm32l476xx.s
  ICCARM.CCIncludePath2: C:\Users\nickh\Desktop\embedded\stm32l476 drivers\drivers\inc; C:\Users\nickh\Desktop\embedded\stm32l476 drivers\drivers\startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32l476_drivers.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drivers/inc
    drivers/inc/: gpio_driver.h i2c_driver.h rcc_driver.h spi_driver.h stm32l476.h usart_driver.h
  group drivers/src
    drivers/src/: gpio_driver.c i2c_driver.c rcc_driver.c spi_driver.c usart_driver.c
  group drivers/startup
    drivers/startup/: startup.c startup_stm32l476xx.s
  group src
    src/: main.c
